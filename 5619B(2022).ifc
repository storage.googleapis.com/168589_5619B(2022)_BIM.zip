Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-08-19T17:34:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 19 17:34:19 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{AF001087-F92D-48A2-95B4-F804B2E4500D}\ifc * Database version: 5507 * Database creation date: Fri Aug 19 17:34:18 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 19 17:34:18 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 19 17:34:18 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 5619B Washbasin faucet, 5619B(2022):5619B Washbasin faucet:301704
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 208.5 mm; NominalHeight: 171.4 mm; NominalWidth: 50 mm
Type - General - Author: BIMStone; BIMObjectName: 5619B(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_100; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/08/2022
Type - Green Building Properties - EAN Number: 6414150100635; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110389; Noise Class: I (ISO 3822); NRF Number: 4200593; RSK Number: 8325282; Sales Package dimensions (LxWxH): 585 x 225 x 95; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/5619B; URL REACH: http://static.oras.com/doc/reach; VVS Number: 701655234
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5619B; 3D View: https://static.oras.com/3D/5619B; Catalog Drawing URL: http://static.oras.com/catdrw/5619B; Dimension Drawing URL: http://static.oras.com/dimdrw/5619B; FDV Document URL: http://www.oras.com/datasheet/5619B/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5619B; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/5619B; Interactive AR View URL: https://static.oras.com/AR/5619B; Long Marketing: Oras Clinica washbasin faucet. Firm longer loop-lever (180 mm) offers good usability to all users and situations. Fixed longer spout (150 mm) with nickel-free water channels and laminar water flow. In-built limitation options for water temperature and maximum flow-rate. Connection pipes Cu ø10 mm.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/5619B; Model: 5619B Washbasin faucet; Name_en: 5619B Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5619B; Product Family: Oras Clinica; Product Image URL: http://static.oras.com/image/5619B; Product URL: http://static.oras.com/5619B; Spare-Part Information URL: http://static.oras.com/sp/5619B; Technical DataSheet URL: http://www.oras.com/datasheet/5619B/en; Type Name: 5619B Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Waterways without nickel coating;3S-installation system for safe and simple mounting; Aerator: Laminar stream; Backflow Prevention EN1717: AA; Connection: Copper inlet pipes; Connection Size: Ø10mm; Flow Rate At 300kPa: 0.0734545 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Loop shape;Long shape;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 70000 Pa; Spout Projection: 150 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5619B(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5619B; Name: 5619B Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50 x 210 x 170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0558435 m2; Volume: 0.00179155 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5619B(2022): 5619B Washbasin faucet; Family and Type: 5619B(2022): 5619B Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5619B(2022): 5619B Washbasin faucet; Type Id: 5619B(2022): 5619B Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
